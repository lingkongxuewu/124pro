# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F502 Silicon Labs
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM(0-0xFFF) CLOCK(24000000)
  output: wtu +hex
  c flags: Optimize=8
  c include: .\inc
  group Source Group 1
    ./: STARTUP.A51
    ./src/: Comm.c Delay.c Init.c main.c Send.c Timer.c I2C.c I2C.h Sub.c
