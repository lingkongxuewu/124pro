# Keil uVision project CAN_100T.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F506 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFFF) IROM(0-0x7FFF) CLOCK(50000000)
  output: CAN_100T +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: I2C_tst.c
